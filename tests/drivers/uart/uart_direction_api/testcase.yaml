## tests/drivers/uart/uart_direction_api/testcase.yaml
```yaml
tests:
  drivers.uart.direction:
    tags: drivers
    filter: CONFIG_UART_STM32
    harness: keyboard
```
